## configs/extra/zyntroui_defconfig
```kconfig
BR2_TOOLCHAIN_BUILDROOT_CXX=y
BR2_INIT_BUSYBOX=y
BR2_SYSTEM_BIN_SH_BUSYBOX=y
BR2_PACKAGE_BUSYBOX=y
BR2_TARGET_ROOTFS_TAR=y
```
